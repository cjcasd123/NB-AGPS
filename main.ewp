# IAR project main.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G4 STM8L151G4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: C:\Users\anybo\Desktop\基础功能测试（STM8L）; C:\Users\anybo\Desktop\基础功能测试（STM8L）\HomeWork\MYSTDIO; C:\Users\anybo\Desktop\基础功能测试（STM8L）\HomeWork\SOFTUART; C:\Users\anybo\Desktop\基础功能测试（STM8L）\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: main.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group HomeWork/MYSTDIO
    HomeWork/MYSTDIO/: mystdio.c
  group HomeWork/SOFTUART
    HomeWork/SOFTUART/: softuart.c
  group STM8L15x_StdPeriph_Driver
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_tim2.c
